# Keil uVision project Hard_Fault_Sample.uvprojx, settings and files
target Hard_Fault_Sample (ARM-ADS)
  device: M0A23EC1AC Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Hard_Fault_Sample
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\Library\CMSIS\Core\Include;..\..\..\Library\Device\Nuvoton\M0A21\Include;..\..\..\Library\StdDriver\inc
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M0A21.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M0A21/Source/: system_M0A21.c
    ../../../Library/Device/Nuvoton/M0A21/Source/ARM/: startup_M0A21.s
  group User
    ../: main.c
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
