# Keil uVision project ISP_USCI_I2C.uvprojx, settings and files
target ISP_USCI_I2C (ARM-ADS)
  device: M0A23EC1AC Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: ISP_USCI_I2C
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M0A21\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M0A21_ISP.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M0A21/Source/: system_M0A21.c
    ../: startup_M0A21_ISP.s
  group User
    ../: fmc_user.c isp_user.c targetdev.c main.c usci_i2c_transfer.c
