# Keil uVision project ACMP_CompareDAC.uvprojx, settings and files
target ACMP_CompareDAC (ARM-ADS)
  device: M0A23EC1AC Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: ACMP_CompareDAC
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M0A21\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M0A21.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M0A21/Source/: system_M0A21.c
    ../../../../Library/Device/Nuvoton/M0A21/Source/ARM/: startup_M0A21.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c acmp.c clk.c dac.c gpio.c sys.c uart.c
