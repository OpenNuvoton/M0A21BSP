# IAR project PWM_DoubleBuffer_PeriodLoadingMode.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M0A21 series Nuvoton M0A21 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M0A21\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PWM_DoubleBuffer_PeriodLoadingMode.bin
  ILINK.IlinkOutputFile: PWM_DoubleBuffer_PeriodLoadingMode.out
  ILINK.IlinkIcfFile: PWM_DoubleBuffer_PeriodLoadingMode.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M0A21/Source/IAR/: startup_M0A21.s
    ../../../../Library/Device/Nuvoton/M0A21/Source/: system_M0A21.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c pwm.c retarget.c sys.c uart.c
  group User
    ../: main.c
