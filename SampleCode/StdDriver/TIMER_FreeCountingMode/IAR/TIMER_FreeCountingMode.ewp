# IAR project TIMER_FreeCountingMode.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M0A21 series Nuvoton M0A21 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M0A21\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TIMER_FreeCountingMode.bin
  ILINK.IlinkOutputFile: TIMER_FreeCountingMode.out
  ILINK.IlinkIcfFile: TIMER_FreeCountingMode.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS Files
    ../../../../Library/Device/Nuvoton/M0A21/Source/IAR/: startup_M0A21.s
    ../../../../Library/Device/Nuvoton/M0A21/Source/: system_M0A21.c
  group Library Files
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c timer.c uart.c
  group Source Files
    ../: main.c
